# Keil uVision project STM32F103C8T6.uvprojx, settings and files
target stm32f103C8T6_mode (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: c8t6 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\User;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\OLED;..\HARDWARE\Systerm;..\HARDWARE\LED;..\HARDWARE\DS1302;..\HARDWARE\DHT12;..\HARDWARE\KEY;..\..\fl\fl\BELLRING;..\..\fl\fl\TIMER;..\HARDWARE\esp8266;..\HARDWARE\Weather;..\HARDWARE\TIMER;..\HARDWARE\BELLRING
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group System
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group Core
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SysLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_i2c.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/Systerm/: Systerm.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DS1302/: DS1302.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/esp8266/: esp8266.c
    ../HARDWARE/Weather/: weather.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/BELLRING/: bellring.c
